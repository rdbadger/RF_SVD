options:
  parameters:
    author: David Badger
    description: sigMF sample collection
    generate_options: qt_gui
    id: file_play
    output_language: python
    title: Play sigMF recordings
  states: {}

blocks:
- name: antenna
  id: variable_qtgui_chooser
  parameters:
    label: Antenna
    label0: '"TX/RX"'
    label1: '"RX2"'
    num_opts: '2'
    option0: '"TX/RX"'
    option1: '"RX2"'
    type: string
    value: '"TX/RX"'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    orient: Qt.Horizontal
    start: 400e6
    step: 100e3
    stop: 6e9
    value: 433.7e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 1e6
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/david/Desktop/prefix/radio/sigMF data collect_val/Lora_mule/lora125/UHF_lora125_val1_gain30.sigmf-data
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/david/sigMF_ML/RF_SVD/clean_speech/IQ_files/uv5r_iq/UHF_NFM_UV5R_clean1.sigmf-data
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}
- name: sigmf_source_0
  id: sigmf_source
  parameters:
    filename: /home/david/sigMF_ML/RF/ramdisk/test1.sigmf-data
    repeat: 'True'
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    clock_rate: '0.0'
    clock_source0: gpsdo
    dc_offs_enb0: 'False'
    dev_addr: '"192.168.10.2"'
    dev_args: '"type=N210"'
    gain0: gain
    iq_imbal_enb0: 'False'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_1, '0', blocks_throttle_0, '0']
- [blocks_file_source_1, '0', fosphor_qt_sink_c_0_0, '0']
- [blocks_throttle_0, '0', uhd_usrp_sink_0, '0']
- [sigmf_source_0, '0', blocks_throttle_0, '0']
- [sigmf_source_0, '0', fosphor_qt_sink_c_0_0, '0']

metadata:
  file_format: 1
